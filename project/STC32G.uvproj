# Keil uVision project STC32G.uvproj, settings and files
target Debug (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G +hex
  group LIB
    ../driver/lib/: stc_usb_hid_32.LIB STC32_MDU32_V1.1.LIB SEEKFREE_CONFIG.LIB
  group lib_header
    ../driver/include/: stc32_stc8_usb.h STC32G_ADC.h STC32G_Clock.h STC32G_Compare.h STC32G_Delay.h STC32G_DMA.h STC32G_EEPROM.h STC32G_Exti.h STC32G_GPIO.h STC32G_I2C.h STC32G_LCM.h STC32G_LIN.h STC32G_NVIC.h STC32G_PWM.h STC32G_RTC.h STC32G_Soft_I2C.h STC32G_Soft_UART.h STC32G_SPI.h STC32G_Switch.h STC32G_Timer.h STC32G_UART.h STC32G_USART_LIN.h STC32G_WDT.h
  group lib_source
    ../driver/src/: STC32G_ADC.c STC32G_Clock.c STC32G_Compare.c STC32G_Delay.c STC32G_DMA.c STC32G_EEPROM.c STC32G_Exti.c STC32G_GPIO.c STC32G_I2C.c STC32G_LCM.c STC32G_LIN.c STC32G_NVIC.c STC32G_PWM.c STC32G_RTC.c STC32G_Soft_I2C.c STC32G_Soft_UART.c STC32G_SPI.c STC32G_Timer.c STC32G_UART.c STC32G_USART_LIN.c STC32G_WDT.c
  group lib_interupt
    ../driver/isr/: STC32G_ADC_Isr.c STC32G_CAN_Isr.c STC32G_Compare_Isr.c STC32G_DMA_Isr.c STC32G_Exti_Isr.c STC32G_GPIO_Isr.c STC32G_I2C_Isr.c STC32G_LCM_Isr.c STC32G_LIN_Isr.c STC32G_PWM_Isr.c STC32G_RTC_Isr.c STC32G_SPI_Isr.c STC32G_Timer_Isr.c STC32G_UART_Isr.c
  group peripheral
    ../peripheral/src/: motor.c exti.c screen.c timer.c uart.c signal_acq.c encoder.c telemeter.c gyroscope.c iic.c
    ../peripheral/header/: motor.h exti.h screen.h timer.h uart.h signal_acq.h encoder.h telemeter.h gyroscope.h iic.h
  group user_include
    ../user/include/: type_def.h config.h board.h cevent.h cpost.h control.h pid.h interupt.h
    ./: kalman.h
  group user_c
    ../user/src/: main.c isr.asm board.c cevent.c cpost.c control.c interupt.c pid.c
    ./: kalman.c
